SRC_URI += "file://bsp.cfg \
            file://user_2018-07-19-11-39-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
